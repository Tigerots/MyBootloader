# Keil uVision project STM32F1xx_BootLoader.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Reader_IAP +hex
  c flags: v6Lang=3 v6LangP=3 wLevel=3
  c include: .\app\include;..\FWLib\library\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MyApp
    ./app/source/: Flash.c LED.c main.c stm32f10x_it.c
  group FWlib
    ../FWLib/library/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_nvic.c stm32f10x_systick.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_wwdg.c
  group RVMDK
    ./: vectors.s cortexm3_macro.s
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
