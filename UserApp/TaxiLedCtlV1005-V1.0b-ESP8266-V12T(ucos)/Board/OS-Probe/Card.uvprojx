# Keil uVision project Card.uvprojx, settings and files
target Card (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Card +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c include: ..\OS-Probe;..\..\uCOS-II\Source;..\..\CPU\ST\STM32\inc;..\BSP;..\..\uCOS-II\Ports\ARM-Cortex-M3\RealView;..\..\uCOS-II\uC-CPU\ARM-Cortex-M3;..\..\uCOS-II\uC-LIB;..\..\USBLib\inc;..\BSP\usb
  memory RVCT4: ROM 0x8008000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../BSP/: stm32f10x_it.c my_iap.c
    ./: App_Top.c EspWifi.c
  group uCOSII/Source
    ../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII/Port
    ../../uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_cpu_c.c os_dbg.c os_cpu_a.asm os_cpu.h
  group uCOSII/CPU
    ../../uCOS-II/uC-CPU/ARM-Cortex-M3/: cpu.h cpu_a.asm cpu_def.h
  group BSP
    ../BSP/: MyApp.c bsp.c vectors.s Uart.c CPU_Flash.c
    ./: MyConvert.c MBI5024Dev.c
  group CPU
    ../../CPU/ST/STM32/src/: stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_systick.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_flash.c
    ../../CPU/ST/STM32/: cortexm3_macro.s
software components: CMSIS:CORE 4.1.0
