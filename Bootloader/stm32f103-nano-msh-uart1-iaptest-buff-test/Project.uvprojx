# Keil uVision project Project.uvprojx, settings and files
target stm32f103-led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103-msh +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_HAL_DRIVER,STM32F103xB
  c include: libraries/STM32F1xx_HAL_Driver/Inc;libraries/STM32F1xx_HAL_Driver/Inc/Legacy;libraries/CMSIS/Device/ST/STM32F1xx/Include;libraries/CMSIS/Include;.\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    applications/: main.c
  group STM32-HAL
    ./libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
    libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
software components: CMSIS:CORE 5.1.2, RTOS:kernel 3.1.3, RTOS:shell 3.1.3
