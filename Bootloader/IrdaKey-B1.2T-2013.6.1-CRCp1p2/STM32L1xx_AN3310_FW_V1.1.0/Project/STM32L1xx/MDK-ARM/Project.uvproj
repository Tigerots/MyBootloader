# Keil uVision project Project.uvproj, settings and files
target STM32L152-EVAL (ARM-ADS)
  device: STM32L152VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152-EVAL
  c flags: wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\..\..\Libraries\CMSIS\Include;..\inc;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\STM32L152-EVAL\STM32L152-EVAL.sct
  group User
    ../src/: main.c stm32l1xx_it.c common.c SpiFlash.c MyApp.c MyFile.c crc.c AES.c rsa.c flash_if.c
  group StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c stm32l1xx_rtc.c stm32l1xx_pwr.c stm32l1xx_wwdg.c stm32l1xx_flash_ramfunc.c stm32l1xx_tim.c stm32l1xx_iwdg.c
  group CMSIS
    ../src/: system_stm32l1xx.c
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
    ../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group MDK-ARM
    ./: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s
  group Doc
    ../: readme.txt
target STM32L152D-EVAL (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Card +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o .\STM32L152-EVAL\card.bin .\STM32L152-EVAL\card.axf
  c flags: Optim=2 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD, USE_STM32L152D_EVAL
  c include: ..\..\..\Libraries\CMSIS\Include;..\inc;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL;..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
